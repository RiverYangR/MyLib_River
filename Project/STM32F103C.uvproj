# Keil uVision project STM32F103C.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Mylib;..\Libraries;..\CM3;..\User;..\MyApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c
  group app
    ../MyApp/: display.c key_app.c ledcontrol.c app_param.c SysTime.c
  group Bsp
    ../Mylib/: delay.c iic.c pca9956.c can.c key.c oled.c tim2.c bsp_init.c
  group Libraries
    ../Libraries/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
